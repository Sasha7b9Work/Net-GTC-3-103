# Keil uVision project GTC-3.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC536)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GTC-3 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB, __cplusplus
  c misc: --cpp
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\CDC;..\common\STM32Cube_F1\Drivers\STM32F1xx_HAL_Driver\Inc;..\common\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F1\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\common\STM32Cube_F1\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F1
    ../common/STM32Cube_F1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd.c stm32f1xx_hal_cortex.c stm32f1xx_ll_usb.c stm32f1xx_hal_dma.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group src
    ./src/: main.cpp Log.cpp Log.h defines.h Device.cpp Device.h Measures.cpp Measures.h
  group Display
    ./src/Display/: Colors.cpp Colors.h Display.cpp Display.h Zones.cpp Zones.h
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font8.inc
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h InterCom.cpp InterCom.h Keyboard.cpp Keyboard.h Beeper.cpp Beeper.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f103xb.s system_stm32f1xx.c
  group Hardware/CDC
    ./src/Hardware/CDC/: usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h CDC.h CDC.cpp
    ../common/STM32Cube_F1/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../common/STM32Cube_F1/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.cpp HAL.h HAL_I2C.cpp HAL_IT.cpp HAL_CONF.h HAL_RTC.cpp HAL_USART_HC12.cpp HAL_ROM.cpp HAL_ADC.cpp HAL_PINS.cpp HAL_PINS.h HAL_SPI1.cpp
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h
  group Menu/Pages
    ./src/Menu/Pages/: PageDisplay.cpp PageHC12.cpp Pages.cpp Pages.h PageSystem.cpp PageMeasures.cpp
  group Modules/BME280
    ./src/Modules/BME280/: BME280.cpp BME280.h bme280_defs.h bme280_driver.c bme280_driver.h
  group Modules/HC12
    ./src/Modules/HC12/: HC12.cpp HC12.h
  group Modules/ST7735
    ./src/Modules/ST7735/: ST7735.cpp ST7735.h
  group Modules/W25Q80DV
    ./src/Modules/W25Q80DV/: W25Q80DV.cpp W25Q80DV.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h
  group Storage
    ./src/Storage/: Storage.cpp Storage.h MemoryStorage.cpp MemoryStorage.h
  group Utils
    ./src/Utils/: Math.h Buffer.h Math.cpp Values.cpp Values.h Debug.cpp Debug.h
  group Utils/Text
    ./src/Utils/Text/: String.cpp String.h Text.cpp Text.h
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC536)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GTC-3 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB, __cplusplus
  c misc: --cpp
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
